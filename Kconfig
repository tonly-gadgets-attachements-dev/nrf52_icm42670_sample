## Kconfig
```kconfig
menu "My Out-of-Tree Drivers"
rsource "drivers/Kconfig"
endmenu

menu "Zephyr Kernel"
source "Kconfig.zephyr"
endmenu
```
